# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\hardware\KEY;..\..\hardware\OLED;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\hardware\time;..\..\hardware\exti;..\..\hardware\encoder;..\..\hardware\IIC;..\..\hardware\MPU6050;..\..\hardware\Stepper_motor;..\..\hardware\incremental_pid;..\..\hardware\LED;..\..\hardware\BEEP;..\..\SYSTEM\delay;..\..\hardware\time3_pwm0;..\..\hardware\time3_pwm1;..\..\hardware\time3_pwm2;..\..\hardware\24L01;..\..\hardware\SPI;..\..\Libraries\FWlib\inc;..\..\hardware\Bluetooth;..\..\hardware\zigbee;..\..\hardware\ultrasonic;..\..\Libraries\FWlib\inc;..\..\hardware\adc;..\..\application\compute
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group hardware
    ../../hardware/KEY/: key.c init_key.c
    ../../hardware/OLED/: OLED.c
    ../../hardware/time/: time.c
    ../../hardware/exti/: exti.c
    ../../hardware/encoder/: encoder.c
    ../../hardware/IIC/: iic_analog.c
    ../../hardware/MPU6050/: mpu6050.c
    ../../hardware/Stepper_motor/: steppermotor.c
    ../../hardware/incremental_pid/: incrementalpid.c
    ../../hardware/LED/: led.c
    ../../hardware/BEEP/: beep.c
    ../../hardware/time3_pwm0/: pwm0.c
    ../../hardware/time3_pwm1/: pwm1.c
    ../../hardware/time3_pwm2/: pwm2.c
    ../../hardware/24L01/: 24l01.c
    ../../hardware/SPI/: spi.c
    ../../hardware/Bluetooth/: Bluetooth.c
    ../../hardware/zigbee/: zigbee.c
    ../../hardware/ultrasonic/: ultrasonic.c
    ../../hardware/adc/: adc.c
  group system
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
    ../../SYSTEM/delay/: delay.c
  group application
    ../../application/compute/: compute.c
